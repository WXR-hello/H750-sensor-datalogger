# Keil uVision project Project.uvprojx, settings and files
target H750_UART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(25000000) ELITTLE
  output: H750_IMU_USB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ..\Inc;..\User;..\User\sd;..\User\fatfs;..\User\usbhost;..\User\encoder;..\MDK-ARM;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\H750XB_Flash.sct
  group Application/MDK-ARM
    ../User/touch/: bsp_i2c_touch.c bsp_touch_gtxx.c
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc_ex.c stm32h7xx_hal_adc.c
    ./: startup_stm32h750xx.s H750XB_Flash.sct
  group Application/User/Core
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c wit_c_sdk.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_sdram.c stm32h7xx_hal_mdma.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c
  group User/LCD
    ../User/lcd/: bsp_lcd.c
    ../User/sdram/: bsp_sdram.c
    ../User/mpu/: bsp_mpu.c
    ../User/fonts/: font_cn.c font_cn_data.c
  group User/SD
    ../User/sd/: bsp_sd.c imu_sdlog.c
    ../User/fatfs/: ff.c ffunicode.c diskio.c
  group Doc
    ../: README.md
  group User/Encoder
    ../User/encoder/: bsp_encoder.c
  group User/USB
    ../User/usbhost/: usb_host.c usbh_conf.c usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c usbh_cdc.c
  group User/Relay
    ./: relay.c
  group force
    ./: force.h force.c
  group User/IMU
    ./: imu.h imu.c
